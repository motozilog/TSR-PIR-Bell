# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.0
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TSR-PIR-Bell +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\IDEsupport\MDK;..\Libraries\inc;..\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    ../IDEsupport/MDK/: startup_cw32l010.s
    ../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: main.c interrupts_cw32l010.c bsp_chirp.c bsp_adc.c bsp_full.c bsp_key.c bsp_pir.c bsp_systick.c bsp_uart.c app_chirp.c bsp_led.c bsp_rtc.c utils.c app_config_mgr.c
  group Driver
    ../Libraries/src/: cw32l010_sysctrl.c cw32l010_uart.c cw32l010_gpio.c cw32l010_adc.c cw32l010_rtc.c cw32l010_flash.c cw32l010_iwdt.c
  group Doc
    ../: readme.txt
  group Utilities
    ../Utilities/: retarget.c
software components: CMSIS:CORE 5.5.0
